# Keil uVision project Project.uvprojx, settings and files
target HIGH RESOLUTION (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: POWER +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: AD7792
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\ucCos_App;..\USER\uC-CPU;..\USER\uC-LIB;..\USER\uCOS-II;..\USER\uCOS-VIEW;..\USER\GLCD;..\USER\TouchPanel;..\USER\uCGUI;..\USER\uCGUI\Config;..\USER\uCGUI\inc;..\uCGUI_LIB\USER\uCGUI\AntiAlias;..\uCGUI_LIB\USER\uCGUI\Config;..\uCGUI_LIB\USER\uCGUI\ConvertColor;..\uCGUI_LIB\USER\uCGUI\ConvertMono;..\uCGUI_LIB\USER\uCGUI\Core;..\uCGUI_LIB\USER\uCGUI\Font;..\uCGUI_LIB\USER\uCGUI\GUIDemo;..\uCGUI_LIB\USER\uCGUI\GUIDemo2;..\uCGUI_LIB\USER\uCGUI\JPEG;..\uCGUI_LIB\USER\uCGUI\JPEG\Image;..\uCGUI_LIB\USER\uCGUI\MemDev;..\uCGUI_LIB\USER\uCGUI\MultiLayer;..\uCGUI_LIB\USER\uCGUI\Widget;..\uCGUI_LIB\USER\uCGUI\WM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h user_systick.c USE.c RTC_Time.c KEY_BOARD.c mainpage.c AD7792.c Communication.c USBTMC.c SCPI.c
    ../USER/ucCos_App/: uctsk_Task.c app_cfg.h includes.h uctsk_OSMeasure.c
  group TouchPanel
    ../USER/TouchPanel/: TouchPanel.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_systick.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_dbg.c os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../USER/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/CPU
    ../USER/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../USER/uC-CPU/: cpu_def.h
  group uC-OS-II/LIB/Source
    ../USER/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group uC-OS-II/LIB/Port
    ../USER/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uC-OS-II/VIEW/Source
    ../USER/uCOS-VIEW/Source/: os_view.c os_view.h
  group uC-OS-II/VIEW/Port
    ../USER/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group uCOS-Ⅱ/GUI_X
    ../USER/uCGUI/: GUI_X_uCOS.c GUI_X_Touch.c
  group Doc
    ../: readme.txt
  group usblib
    ../USER/usb/usb_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group usbapp
    ../USER/usb/usb_app/: usb_pwr.c usb_desc.c usb_endp.c usb_hwconfig.c usb_istr.c usb_prop.c
  group bsp
    ../USER/BSP/: bsp.c
target LOWE RESOLUTION (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: POWER +hex
  c flags: Optim=1 OneElfS=1
  c define: LOWER_RESOLUTION
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HIGH RESOLUTION_IAP (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: POWER +hex
  c flags: Optim=1 OneElfS=1
  c define: IAP_CONFIG,AD7792
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target LOWE RESOLUTION_IAP (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: POWER +hex
  c flags: Optim=1 OneElfS=1
  c define: LOWER_RESOLUTION,IAP_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HIGH_RESOLUTION_CH1_RIGHT (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: POWER +hex
  c flags: Optim=1 OneElfS=1
  c define: HIGHER_RESOLUTION,CH1_RIGHT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HIGH_CH1_RIGHT_IAP (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: POWER +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o D:\POWER.bin  D:\POWER.axf
  c flags: Optim=1 OneElfS=1
  c define: HIGHER_RESOLUTION,IAP_CONFIG,CH1_RIGHT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
